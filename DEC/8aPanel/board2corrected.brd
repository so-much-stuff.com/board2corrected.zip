# EAGLE board board2corrected (EAGLE 4.11), part 2 of 2
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
MEMSTART\  (via drill 0.61) (continued)
  Top 0.254: v194.56,23.37 194.06,23.88 194.06,37.34 191.52,39.88 191.52,43.69 188.98,46.23 188.98,65.53 v183.64,70.87 | v179.58,70.87 171.2,79.25 171.2,83.06 166.88,87.38 166.88,87.88 164.08,90.68 154.94,90.68 v154.94,86.61 | v141.22,85.6 138.68,85.6 v137.67,84.58 | v88.9,79.5 85.34,83.06 49.53,83.06 49.53,80.26 48.51,79.25 J2.26
  Bottom 0.254: v194.56,23.37 215.9,23.37 217.93,21.34 E23.12 | v179.58,70.87 v183.64,70.87 | v154.94,86.61 153.92,85.6 v141.22,85.6 | v137.67,84.58 137.16,84.07 107.19,84.07 105.16,82.04 105.16,79.5 v88.9,79.5
MH0  (via drill 0.61)
  Top 0.254: 222.5,76.71 225.81,80.01 E20.9 | 222.5,76.71 222,76.2 222,42.67 221.23,41.91 E22.11 | v268.48,77.98 267.72,78.74 267.72,83.82 261.62,89.92 222.5,89.92 222.5,76.71
  Bottom 0.254: v268.48,77.98 312.17,77.98 314.45,80.26 E8.13
MH0\  (via drill 0.61)
  Top 0.254: E21.9 226.31,62.23 227.58,63.5 v227.58,68.58 227.58,79.25 228.35,80.01 E20.8 | v312.67,69.6 312.67,70.36 314.71,72.39 E8.2
  Bottom 0.254: E8.2 315.47,74.68 319.79,78.99 323.34,78.99 324.61,80.26 E8.9 | E20.12 218.95,80.26 219.71,79.5 227.33,79.5 228.09,80.26 E20.8 | v312.67,69.6 312.17,69.09 245.62,69.09 245.11,68.58 v227.58,68.58
MPXA  (via drill 0.61)
  Top 0.254: 240.28,22.35 241.05,21.59 E19.14 | 240.28,22.35 240.28,38.61 | 240.28,38.61 241.05,39.37 E18.14 | 240.28,38.61 240.28,58.93 241.05,59.69 E17.14 | v100.58,77.72 99.57,76.71 99.57,26.92 v99.31,26.67 | v121.92,26.16 123.7,24.38 123.7,11.94 v131.83,3.81 | v134.62,3.81 135.13,3.3 172.97,3.3 v172.97,5.33 | v171.7,6.6 171.45,6.86 171.45,16.76 171.7,17.02 171.7,23.37 v172.21,23.88 | v191.52,23.37 193.04,24.89 v193.04,26.67 | v223.52,24.64 225.04,23.11 225.04,10.16 225.81,9.4 240.28,9.4 240.28,22.35
  Bottom 0.254: v100.58,77.72 106.17,77.72 108.71,80.26 J4.14 | v99.31,26.67 99.82,26.16 v121.92,26.16 | v134.62,3.81 v131.83,3.81 | v171.7,6.6 v172.97,5.33 | v172.21,23.88 172.72,23.37 v191.52,23.37 | v193.04,26.67 195.33,28.96 205.74,28.96 206.5,28.19 207.26,28.19 207.52,28.45 214.38,28.45 218.19,24.64 v223.52,24.64
MPXB  (via drill 0.61)
  Top 0.254: 237.74,30.99 237.74,14.73 238.51,13.97 E19.2 | 237.74,30.99 238.51,31.75 E18.2 | 237.74,30.99 237.74,51.31 238.51,52.07 E17.2 239.01,54.61 239.78,55.37 v239.78,86.11 | v118.11,88.14 112.27,82.3 J4.13 | v178.82,84.33 179.32,83.82 v179.32,79.25 | v200.41,79.25 v207.26,86.11
  Bottom 0.254: v118.11,88.14 118.62,88.65 145.54,88.65 146.56,89.66 161.29,89.66 162.31,88.65 174.24,88.65 178.56,84.33 v178.82,84.33 | v179.32,79.25 179.83,79.76 199.9,79.76 v200.41,79.25 | v207.26,86.11 v239.78,86.11
MSIRDIS\  (via drill 0.61)
  Top 0.254: v143.26,68.33 143.26,63.5 144.53,62.23 E31.11 | v78.74,67.56 78.74,78.23 J2.2
  Bottom 0.254: v143.26,68.33 142.75,67.82 131.32,67.82 130.81,68.33 119.13,68.33 117.35,66.55 82.8,66.55 82.3,67.06 79.25,67.06 v78.74,67.56
N$1
  Top 0.254: E10.6 325.37,31.75 326.64,30.48 326.64,28.7 334.26,21.08 334.26,18.29 341.63,10.92 349,10.92 349,35.56 352.81,39.37 E6.12
  Bottom 0.254: E2.12 375.41,41.66 374.65,42.42 364.74,42.42 361.19,38.86 354.33,38.86 353.57,39.62 E6.12
N$2
  Top 0.254: E9.6 325.37,54.61 326.64,55.88 326.64,68.07 339.85,81.28 341.88,81.28 341.88,79.5 346.96,74.42 346.96,68.07 352.81,62.23 E5.12
  Bottom 0.254: E1.12 375.41,61.98 374.65,62.74 364.74,62.74 361.19,59.18 354.33,59.18 353.57,59.94 E5.12
N$3
  Bottom 0.254: E9.2 315.47,54.36 316.99,55.88 343.92,55.88 344.68,55.12 349.25,55.12 350.01,54.36 E5.4 351.03,54.36 352.55,55.88 376.43,55.88 380.49,59.94 E1.10
N$4
  Bottom 0.254: 351.79,51.56 321.31,51.56 320.55,52.32 E9.4 | 351.79,51.56 352.55,52.32 E5.5 | 351.79,51.56 376.94,51.56 376.94,54.1 377.95,55.12 382.02,55.12 382.02,62.23 381.51,62.74 379.73,62.74 378.97,61.98 E1.11
N$5
  Bottom 0.254: 349.25,31.24 316.23,31.24 315.47,32 E10.2 | 349.25,31.24 350.01,32 E6.4 | 349.25,31.24 361.19,31.24 365.51,35.56 376.43,35.56 380.49,39.62 E2.10
N$6
  Bottom 0.254: E10.4 320.55,34.04 322.07,35.56 351.03,35.56 352.55,34.04 E6.5 353.57,34.04 355.6,36.07 374.4,36.07 377.95,39.62 E2.11
N$7
  Top 0.254: E11.6 325.63,11.68 327.41,9.91 352.04,9.91 352.04,18.29 352.81,19.05 E7.12
  Bottom 0.254: E3.12 375.41,21.34 374.65,22.1 364.74,22.1 361.19,18.54 354.33,18.54 353.57,19.3 E7.12
N$8
  Bottom 0.254: 349.25,10.92 316.23,10.92 315.47,11.68 E11.2 | 349.25,10.92 350.01,11.68 E7.4 | 349.25,10.92 376.94,10.92 376.94,13.46 377.95,14.48 380.75,14.48 380.75,19.05 E3.10
N$9
  Bottom 0.254: 351.03,15.24 322.07,15.24 320.55,13.72 E11.4 | 351.03,15.24 352.55,13.72 E7.5 | 351.03,15.24 373.89,15.24 377.95,19.3 E3.11
N$10
  Bottom 0.254: E19.3 241.81,11.68 242.57,10.92 259.08,10.92 263.14,14.99 263.14,15.75 265.43,15.75 266.19,14.99 E15.2
N$11  (via drill 0.61)
  Top 0.254: v246.89,9.91 246.89,11.18 246.63,11.43 E19.5
  Bottom 0.254: v246.89,9.91 247.4,10.41 267.46,10.41 268.73,11.68 279.4,11.68 280.42,12.7 280.42,15.75 275.59,15.75 274.83,14.99 E15.5
N$12  (via drill 0.61)
  Top 0.254: v252.98,14.48 260.6,14.48 v262.89,12.19
  Bottom 0.254: v252.98,14.48 245.11,14.48 244.35,13.72 E19.4 | v262.89,12.19 278.13,12.19 278.89,12.95 E15.7
N$13  (via drill 0.61)
  Top 0.254: v252.98,24.38 252.98,17.78 249.17,13.97 E19.6
  Bottom 0.254: v252.98,24.38 253.49,23.88 274.32,23.88 275.84,22.35 275.84,19.81 278.13,19.81 278.89,20.57 E15.10
N$14
  Bottom 0.254: E19.13 244.35,21.34 246.38,23.37 273.05,23.37 273.81,22.61 E15.12
N$15  (via drill 0.61)
  Top 0.254: v266.7,18.54 266.7,20.32 E15.15
  Bottom 0.254: v266.7,18.54 250.19,18.54 249.43,19.3 E19.11
N$16  (via drill 0.61)
  Top 0.254: v259.59,52.58 259.59,34.54 246.63,21.59 E19.12
  Bottom 0.254: v259.59,52.58 260.35,53.34 262.13,53.34 263.14,54.36 263.14,55.12 265.43,55.12 266.19,54.36 E13.2
N$17  (via drill 0.61)
  Top 0.254: v272.8,19.81 273.3,20.32 273.3,37.34 275.34,39.37 275.34,43.69 273.81,45.21 273.81,52.32 E13.5
  Bottom 0.254: v272.8,19.81 266.7,19.81 265.94,19.05 261.11,19.05 258.06,22.1 252.73,22.1 251.97,21.34 E19.10
N$18
  Top 0.254: E18.3 241.55,31.75 245.36,27.94 245.36,16 247.9,13.46 247.9,8.64 249.68,6.86 267.72,6.86 267.72,7.87 272.03,12.19 280.42,12.19 280.42,51.31 279.65,52.07 E13.7
N$19  (via drill 0.61)
  Top 0.254: v246.89,63.75 245.36,62.23 245.36,35.05 246.13,34.29 E18.5
  Bottom 0.254: v246.89,63.75 247.4,63.25 277.62,63.25 278.89,61.98 E13.10
N$20  (via drill 0.61)
  Top 0.254: v244.86,62.99 244.86,35.05 244.09,34.29 E18.4
  Bottom 0.254: v244.86,62.99 245.11,62.74 273.05,62.74 273.81,61.98 E13.12
N$21  (via drill 0.61)
  Top 0.254: v255.27,57.66 255.27,51.56 251.46,51.56 247.9,48.01 247.9,35.05 248.67,34.29 E18.6
  Bottom 0.254: v255.27,57.66 256.03,58.42 264.67,58.42 266.19,59.94 E13.15
N$22
  Bottom 0.254: E18.13 244.35,39.62 246.38,37.59 272.03,37.59 275.34,34.29 275.34,31.24 267.97,31.24 267.21,32 E14.2
N$23  (via drill 0.61)
  Top 0.254: v249.17,35.56 249.17,39.37 E18.11
  Bottom 0.254: v249.17,35.56 272.29,35.56 273.81,34.04 E14.5
N$24  (via drill 0.61)
  Top 0.254: v247.4,30.23 247.4,38.61 246.63,39.37 E18.12
  Bottom 0.254: v247.4,30.23 247.65,30.48 256.29,30.48 256.54,30.73 277.62,30.73 278.89,32 E14.7
N$25  (via drill 0.61)
  Top 0.254: v254.76,46.99 254.76,44.96 251.71,41.91 E18.10 | v274.83,47.75 279.15,43.43 279.15,41.91 E14.10
  Bottom 0.254: v254.76,46.99 255.52,47.75 v274.83,47.75
N$26  (via drill 0.61)
  Top 0.254: v252.98,78.49 252.98,63.5 251.71,62.23 E17.10
  Bottom 0.254: v252.98,78.49 256.29,81.79 265.43,81.79 266.19,81.03 E12.15
N$27  (via drill 0.61)
  Top 0.254: v250.44,77.22 250.44,72.9 248.41,70.87 248.41,64.01 246.63,62.23 E17.12
  Bottom 0.254: v250.44,77.22 250.7,77.47 266.45,77.47 268.22,79.25 268.22,81.79 273.05,81.79 273.81,81.03 E12.12
N$28  (via drill 0.61)
  Top 0.254: v249.43,66.04 249.43,62.48 249.17,62.23 E17.11 | v277.37,66.04 278.38,67.06 278.38,77.98 279.15,78.74 E12.10
  Bottom 0.254: v249.43,66.04 v277.37,66.04
N$29  (via drill 0.61)
  Top 0.254: v278.13,65.02 279.15,66.04 279.15,71.12 E12.7
  Bottom 0.254: v278.13,65.02 277.11,65.02 276.86,65.28 264.41,65.28 264.16,65.02 243.33,65.02 243.33,62.99 243.59,62.74 243.59,62.23 E17.13
N$30  (via drill 0.61)
  Top 0.254: v266.45,55.88 267.72,54.61 267.72,42.67 266.95,41.91 E14.15
  Bottom 0.254: v266.45,55.88 248.41,55.88 246.89,54.36 E17.5
N$31  (via drill 0.61)
  Top 0.254: v272.8,55.12 273.3,54.61 273.3,42.67 274.07,41.91 E14.12
  Bottom 0.254: v272.8,55.12 270.76,55.12 270.76,52.58 269.75,51.56 242.57,51.56 241.81,52.32 E17.3
N$32  (via drill 0.61)
  Top 0.254: v265.68,58.17 265.68,70.36 266.45,71.12 E12.2
  Bottom 0.254: v265.68,58.17 264.16,56.64 246.63,56.64 244.35,54.36 E17.4
N$33  (via drill 0.61)
  Top 0.254: v250.44,70.1 250.44,55.88 249.17,54.61 E17.6
  Bottom 0.254: v250.44,70.1 252.73,72.39 262.13,72.39 263.14,73.41 263.14,74.17 273.05,74.17 273.81,73.41 E12.5
N$34  (via drill 0.61)
  Top 0.254: v219.46,70.1 219.46,62.99 218.69,62.23 E21.12 | v241.3,70.1 241.3,72.39 E16.3
  Bottom 0.254: v219.46,70.1 v241.3,70.1
N$35
  Bottom 0.254: E24.4 196.09,54.36 196.85,55.12 205.74,55.12 207.52,53.34 212.85,53.34 E21.1
N$36  (via drill 0.61)
  Top 0.254: v208.79,68.07 214.38,62.48 214.38,60.2 216.92,57.66 216.92,39.88 219.46,37.34 219.46,31.24 221.49,31.24 222,31.75 222,38.1 223.27,39.37 E22.10 | v175.77,68.07 175.26,67.56 175.26,63.25 173.74,61.72 173.74,59.69 171.96,57.91 170.94,57.91 170.94,56.39 169.16,54.61 169.16,48.51 | 169.16,48.51 169.16,35.05 169.93,34.29 E29.5 | v156.72,57.4 159,55.12 159,50.29 v160.78,48.51 | 169.16,48.51 v168.91,48.51
  Bottom 0.254: E29.4 168.15,32 169.67,32 E29.5 | v208.79,68.07 v175.77,68.07 | v156.72,57.4 154.94,59.18 135.89,59.18 135.13,59.94 E31.15 | v168.91,48.51 v160.78,48.51
N$37  (via drill 0.61)
  Top 0.254: v167.64,23.88 166.62,22.86 166.62,16 167.39,15.24 E30.4 | v217.17,23.37 216.92,23.62 216.92,38.61 216.15,39.37 E22.13
  Bottom 0.254: v167.64,23.88 168.15,24.38 171.45,24.38 171.96,24.89 186.18,24.89 186.69,24.38 210.06,24.38 210.57,23.88 216.66,23.88 v217.17,23.37
N$38  (via drill 0.61)
  Top 0.254: v226.57,67.06 224.54,65.02 224.54,35.05 223.77,34.29 E22.5 | v312.67,67.06 317.25,71.63 317.25,72.39 E8.3
  Bottom 0.254: v226.57,67.06 v312.67,67.06
N$39  (via drill 0.61)
  Top 0.254: v132.08,7.37 132.08,11.43 E33.1 | v174.75,7.62 176.53,9.4 v176.53,30.73
  Bottom 0.254: v132.08,7.37 132.59,7.87 171.45,7.87 171.7,7.62 v174.75,7.62 | v176.53,30.73 177.04,30.23 187.2,30.23 188.21,31.24 217.17,31.24 217.93,32 E22.3
N$40
  Bottom 0.254: E32.6 145.29,34.04 146.81,35.56 213.87,35.56 215.39,34.04 E22.2
N$41  (via drill 0.61)
  Top 0.254: v214.88,48.51 214.88,35.56 213.61,34.29 E22.1 | v218.44,50.04 219.96,51.56 219.96,69.34 220.47,69.85 220.47,71.88 219.96,72.39 219.96,79.25 220.73,80.01 E20.11 221.23,82.55 221.23,90.42 264.92,90.42 271.53,83.82 271.53,83.31 276.1,83.31 276.86,84.07 358.39,84.07 360.17,82.3 E4.9
  Bottom 0.254: v214.88,48.51 216.41,50.04 v218.44,50.04
N$42
  Bottom 0.254: E25.12 193.55,41.66 194.31,42.42 227.33,42.42 228.09,41.66 E22.8
N$43  (via drill 0.61)
  Top 0.254: v141.73,24.13 141.22,24.64 141.22,41.91 141.73,42.42 141.73,51.82 141.99,52.07 E31.5 | v122.68,24.13 123.19,23.62 123.19,11.18 v130.56,3.81 | v176.28,5.08 176.78,5.59 176.78,8.89 177.55,9.65 v177.55,28.19
  Bottom 0.254: v122.68,24.13 v141.73,24.13 | v130.56,3.81 131.57,2.79 173.99,2.79 v176.28,5.08 | v177.55,28.19 186.69,28.19 D1.C
N$44  (via drill 0.61)
  Top 0.254: v142.24,26.16 142.24,31.75 E32.5 | v181.1,26.67 182.12,27.69 v182.12,56.9 | v202.69,56.9 202.95,57.15 202.95,59.69 E24.8
  Bottom 0.254: v142.24,26.16 142.75,26.67 157.73,26.67 159.26,25.15 162.05,25.15 162.56,25.65 168.15,25.65 169.16,26.67 v181.1,26.67 | v202.69,56.9 v182.12,56.9
N$45  (via drill 0.61)
  Top 0.254: v136.14,15.49 136.14,51.31 136.91,52.07 E31.3 | v124.71,15.49 v124.71,60.2 | v194.31,54.86 194.56,54.61 194.56,43.94 196.6,41.91 196.6,28.7 196.34,28.45 v196.34,26.92
  Bottom 0.254: v124.71,15.49 v136.14,15.49 | v124.71,60.2 127.76,63.25 150.11,63.25 150.62,63.75 151.64,63.75 158.5,56.9 173.74,56.9 174.24,57.4 180.34,57.4 181.86,55.88 190.5,55.88 191.01,56.39 192.79,56.39 v194.31,54.86 | v196.34,26.92 195.07,25.65 189.23,25.65 D2.C
N$46
  Bottom 0.254: E36.9 122.43,22.1 140.97,22.1 141.73,21.34 E33.10
N$47  (via drill 0.61)
  Top 0.254: v206.5,58.17 207.77,56.9 v207.77,27.43
  Bottom 0.254: v206.5,58.17 198.37,58.17 198.37,59.69 E24.10 | v207.77,27.43 210.82,24.38 217.42,24.38 220.47,21.34 E23.11
N$48  (via drill 0.61)
  Top 0.254: v148.84,28.7 148.84,22.86 147.57,21.59 E33.8 | v160.78,30.23 161.54,30.99 161.54,36.32 162.31,37.08 162.31,39.37 E29.15
  Bottom 0.254: v148.84,28.7 150.37,30.23 v160.78,30.23
N$49  (via drill 0.61)
  Top 0.254: v173.99,20.07 173.74,19.81 173.74,7.37 170.18,3.81 135.64,3.81 135.64,14.73 133.6,16.76 v133.6,23.11 | v147.32,23.11 147.83,23.62 147.83,31.24 v148.84,32.26
  Bottom 0.254: v173.99,20.07 174.24,19.81 177.8,19.81 179.58,21.59 186.69,21.59 186.69,20.57 187.45,19.81 201.93,19.81 202.69,20.57 E26.10 | v133.6,23.11 v147.32,23.11 | v148.84,32.26 159.51,32.26 E29.1
N$50  (via drill 0.61)
  Top 0.254: v165.61,64.77 165.61,70.87 165.35,71.12 E27.3 | v183.64,41.91 v183.64,64.52 | E26.15 190.25,22.86 189.74,23.37 v189.74,26.92 189.74,31.5 189.48,31.75 189.48,38.61 190.25,39.37 E25.13 | E30.1 160.27,15.24 161.54,16.51 v161.54,26.16 161.54,29.72 162.31,30.48 162.31,31.75 E29.2
  Bottom 0.254: v165.61,64.77 165.86,64.52 v183.64,64.52 | v183.64,41.91 184.15,42.42 189.23,42.42 189.99,41.66 E25.13 | v189.74,26.92 184.66,26.92 183.9,27.69 178.31,27.69 177.8,27.18 167.39,27.18 166.37,26.16 v161.54,26.16
N$51  (via drill 0.61)
  Top 0.254: v165.61,30.23 165.61,31.5 165.35,31.75 E29.3 | E26.16 187.71,22.86 186.18,24.38 186.18,30.23 187.71,31.75 E25.1
  Bottom 0.254: v165.61,30.23 166.12,29.72 174.24,29.72 176.28,31.75 176.78,31.75 177.29,31.24 186.69,31.24 187.45,32 E25.1
N$52
  Top 0.254: E22.4 220.73,34.29 219.96,35.05 219.96,50.8 220.73,51.56 220.73,52.07 E21.4
  Bottom 0.254: E21.3 218.95,52.32 220.47,52.32 E21.4
N$53
  Bottom 0.254: E25.8 203.71,39.62 205.23,38.1 215.9,38.1 216.66,38.86 224.79,38.86 225.55,39.62 E22.9
N$54
  Top 0.254: D2.A 197.36,25.91 197.36,27.43 D1.A 197.87,28.45 197.87,31.75 E25.5
N$55  (via drill 0.61)
  Top 0.254: v170.43,30.73 170.43,22.86 E30.10 | v166.62,31.24 166.62,51.31 167.39,52.07 E28.4
  Bottom 0.254: 170.94,31.24 v170.43,30.73 | 170.94,31.24 173.99,31.24 174.75,32 E29.7 | 170.94,31.24 v166.62,31.24 133.35,31.24 132.59,32 E32.1
N$56  (via drill 0.61)
  Top 0.254: v161.29,37.34 161.54,37.59 161.54,48.01 162.31,48.77 162.31,52.07 E28.2 | v177.8,37.59 177.8,39.37 E29.9
  Bottom 0.254: E32.2 135.13,34.04 137.16,36.07 158.5,36.07 160.02,37.59 161.04,37.59 v161.29,37.34 161.54,37.34 172.21,37.34 172.47,37.59 v177.8,37.59
N$57  (via drill 0.61)
  Top 0.254: v174.5,56.39 174.24,56.13 174.24,52.07 174.75,51.56 174.75,42.16 175.01,41.91 E29.10 | v135.13,58.67 134.87,58.42 134.87,54.61 E31.2
  Bottom 0.254: v174.5,56.39 147.07,56.39 144.78,58.67 v135.13,58.67
N$58  (via drill 0.61)
  Top 0.254: v148.84,50.55 148.84,58.42 147.57,59.69 E31.10 | v173.74,50.04 174.24,49.53 174.24,43.18 172.97,41.91 E29.11
  Bottom 0.254: v148.84,50.55 149.35,50.04 v173.74,50.04
N$59
  Bottom 0.254: E32.9 145.29,41.66 146.05,42.42 168.91,42.42 169.67,41.66 E29.12
N$60
  Top 0.254: E30.2 162.05,12.95 158.24,9.14 141.22,9.14 141.22,21.84 143.26,23.88 143.26,38.61 142.49,39.37 E32.10
  Bottom 0.254: E29.13 167.13,39.62 166.37,38.86 158.75,38.86 157.99,38.1 144.27,38.1 142.75,39.62 E32.10
N$61  (via drill 0.61)
  Top 0.254: v137.16,27.69 137.16,21.59 E33.12 | v162.56,27.69 164.08,29.21 164.08,38.1 164.85,38.86 164.85,39.37 E29.14
  Bottom 0.254: v137.16,27.69 v162.56,27.69
N$62
  Bottom 0.254: E33.4 140.21,13.72 140.97,14.48 156.46,14.48 158.75,12.19 176.78,12.19 177.29,12.7 186.94,12.7 187.45,12.19 209.55,12.19 210.06,12.7 212.85,12.7 E23.1
N$63
  Bottom 0.254: E11.11 335.79,19.3 337.31,17.78 343.41,17.78 344.93,19.3 E7.15
N$64
  Bottom 0.254: E11.13 330.71,21.34 331.47,22.1 356.87,22.1 357.63,21.34 E7.10
N$65
  Top 0.254: E11.15 324.87,19.05 324.1,18.29 324.1,11.43 326.14,9.4 357.63,9.4 357.63,11.68 E7.7
N$66  (via drill 0.61)
  Top 0.254: v342.9,16.26 345.19,13.97 E7.2
  Bottom 0.254: v342.9,16.26 329.18,16.26 329.18,21.08 328.17,22.1 321.31,22.1 320.55,21.34 E11.17
N$67  (via drill 0.61)
  Top 0.254: v162.56,24.38 162.56,22.86 E30.13 | v153.42,24.64 152.15,25.91 v152.15,68.58 | v171.2,68.58 172.47,69.85 172.47,71.12 E27.6
  Bottom 0.254: v162.56,24.38 162.31,24.64 v153.42,24.64 | v152.15,68.58 v171.2,68.58
N$68  (via drill 0.61)
  Top 0.254: v165.86,27.69 v165.86,24.38 | v153.42,28.7 v153.42,52.58 | v166.37,54.86 165.35,55.88 165.35,59.69 E28.14
  Bottom 0.254: v165.86,24.38 167.39,22.86 E30.11 | v165.86,27.69 164.85,28.7 v153.42,28.7 | v153.42,52.58 154.18,53.34 157.99,53.34 159,54.36 159,55.12 166.12,55.12 v166.37,54.86
N$69
  Top 0.254: E32.3 137.41,34.29 138.68,35.56 138.68,51.31 139.45,52.07 E31.4
N$70  (via drill 0.61)
  Top 0.254: E34.1 104.39,54.61 106.43,56.64 106.43,59.69 E34.15 | v172.47,9.65 172.47,12.7 E30.6 | v118.62,9.91 115.32,13.21 115.32,30.99 114.55,31.75 E35.5 | v110.74,51.56 110.74,35.05 111.51,34.29 E35.4
  Bottom 0.254: E35.4 112.27,32.26 113.79,32.26 E35.5 | v172.47,9.65 171.96,10.16 139.95,10.16 139.7,10.41 119.13,10.41 v118.62,9.91 | v110.74,51.56 105.41,51.56 104.65,52.32 E34.1
N$71  (via drill 0.61)
  Top 0.254: v175.77,46.99 176.28,46.48 176.28,39.37 174.24,37.34 174.24,31.5 173.23,30.48 173.23,23.11 172.97,22.86 E30.9 | v173.23,46.99 172.72,47.5 172.72,52.07 E28.6 | E33.5 142.49,13.97 143.76,15.24 143.76,36.07 147.07,39.37 E32.8 147.07,41.91 147.07,48.01 | 147.07,48.01 147.07,50.04 145.03,52.07 E31.6 | 147.07,48.01 v146.3,48.01
  Bottom 0.254: v175.77,46.99 v173.23,46.99 172.97,46.74 172.72,46.48 155.45,46.48 154.43,47.5 146.81,47.5 v146.3,48.01
N$72
  Top 0.254: E35.10 119.13,41.91 115.32,45.72 115.32,58.93 114.55,59.69 E34.12
N$73  (via drill 0.61)
  Top 0.254: v118.11,51.05 118.11,45.47 121.67,41.91 E35.9
  Bottom 0.254: v118.11,51.05 117.09,52.07 E34.6
N$74  (via drill 0.61)
  Top 0.254: v142.24,70.36 142.24,62.23 E31.12
  Bottom 0.254: v142.24,70.36 143.26,71.37 158.75,71.37 159.51,70.61 166.37,70.61 167.13,71.37 E27.4
N$75
  Top 0.254: E4.5 352.55,74.68 347.73,79.5 343.92,79.5 343.92,82.55 343.41,83.06 322.83,83.06 322.83,82.55 E8.10
  Bottom 0.254: E8.12 318.01,80.26 318.77,79.5 321.31,79.5 322.07,80.26 E8.10
N$76  (via drill 0.61)
  Top 0.254: v165.1,18.54 165.1,15.24 E30.3 | v153.92,18.54 151.38,21.08 151.38,62.23 v150.88,62.74
  Bottom 0.254: v153.92,18.54 v165.1,18.54 | v150.88,62.74 138.43,62.74 137.67,61.98 E31.14
N$77  (via drill 0.61)
  Top 0.254: v153.92,23.37 154.43,23.88 154.43,74.68 155.45,75.69 162.31,75.69 162.31,73.66 E27.2
  Bottom 0.254: v153.92,23.37 163.83,23.37 164.59,22.61 E30.12
N$78
  Top 0.254: E25.6 200.91,31.75 202.18,30.48 202.18,17.27 204.72,14.73 204.72,12.7 205.23,12.19 212.34,12.19 212.34,15.75 215.65,19.05 E23.13
N$79
  Bottom 0.254: E10.11 335.79,40.64 340.87,40.64 341.88,39.62 341.88,38.86 344.17,38.86 344.93,39.62 E6.15
N$80
  Bottom 0.254: E10.13 330.71,41.66 331.47,42.42 356.87,42.42 357.63,41.66 E6.10
N$81  (via drill 0.61)
  Top 0.254: v355.09,43.43 357.12,41.4 357.12,35.05 357.89,34.29 E6.7
  Bottom 0.254: v355.09,43.43 327.41,43.43 325.63,41.66 E10.15
N$82  (via drill 0.61)
  Top 0.254: v337.57,33.02 337.57,42.67 321.56,42.67 320.55,41.66 E10.17
  Bottom 0.254: v337.57,33.02 340.87,33.02 341.88,34.04 341.88,34.8 344.17,34.8 344.93,34.04 E6.2
N$83
  Bottom 0.254: E9.11 335.79,59.94 337.31,58.42 343.41,58.42 344.93,59.94 E5.15
N$84
  Bottom 0.254: E9.13 330.71,61.98 331.47,62.74 356.87,62.74 357.63,61.98 E5.10
N$85  (via drill 0.61)
  Top 0.254: v344.68,56.39 345.19,55.88 345.19,54.61 E5.2
  Bottom 0.254: v344.68,56.39 324.1,56.39 320.55,59.94 E9.17
N$86  (via drill 0.61)
  Top 0.254: v355.09,63.75 357.12,61.72 357.12,55.37 357.89,54.61 E5.7
  Bottom 0.254: v355.09,63.75 327.41,63.75 325.63,61.98 E9.15
N$87
  Top 0.254: E23.9 226.31,21.59 227.58,22.86 227.58,58.93 228.35,59.69 E21.8
N$88
  Top 0.254: C40.1 370.08,77.22 369.06,77.22 C37.1
  Bottom 0.254: E4.6 356.11,72.64 357.63,71.12 366.27,71.12 367.03,71.88 367.03,77.22 367.54,77.22 C37.1
N$89
  Top 0.254: R25.1 366.52,72.14 367.54,72.14 C37.2 369.06,72.14 370.08,72.14 C40.2
  Bottom 0.254: E4.7 358.65,72.64 359.41,71.88 365.25,71.88 R25.1
N$93  (via drill 0.61)
  Top 0.254: v211.84,63.75 208.79,60.71 208.79,18.03 205.99,15.24 E26.8 | v220.98,64.26 220.98,72.39 E20.4
  Bottom 0.254: v211.84,63.75 212.34,64.26 v220.98,64.26
N$94
  Top 0.254: E26.9 205.49,22.86 204.22,24.13 204.22,29.72 201.68,32.26 201.68,38.61 200.91,39.37 E25.9
NUM  (via drill 0.61)
  Top 0.254: v124.97,80.52 125.73,79.76 125.73,11.18 134.11,2.79 177.29,2.79 177.29,7.62 178.05,8.38 178.05,23.62 178.56,24.13 178.56,29.97 176.78,31.75 176.78,49.28 179.58,52.07 v179.58,52.58 | v186.44,53.34 186.94,53.85 v186.94,66.29 | E21.13 215.65,62.23 215.65,62.48 v211.84,66.29 212.09,66.55 212.09,74.68 v214.63,77.22
  Bottom 0.254: v124.97,80.52 122.43,83.06 118.11,83.06 117.35,82.3 J4.11 | v179.58,52.58 180.34,53.34 v186.44,53.34 | v211.84,66.29 v186.94,66.29 | 240.03,83.06 240.79,82.3 E16.12 | 240.03,83.06 232.66,83.06 226.82,77.22 v214.63,77.22 | 240.03,83.06 251.97,83.06 252.22,82.8 277.37,82.8 278.13,83.57 326.14,83.57 326.14,80.01 325.63,79.5 325.37,79.5 320.55,74.68 E8.4
NUMCLK
  Top 0.254: E3.8 385.57,19.3 384.05,19.3 E3.9 383.79,21.59 384.56,22.35 384.56,39.62 | 384.56,39.62 385.57,39.62 E2.8 | 384.56,39.62 384.05,39.62 E2.9 383.79,41.91 384.56,42.67 384.56,59.94 | 384.56,59.94 385.57,59.94 E1.8 | 384.56,59.94 384.05,59.94 E1.9
  Bottom 0.254: E8.6 325.63,72.64 327.15,71.12 356.87,71.12 364.74,63.25 381.76,63.25 383.03,61.98 E1.9
PANLOCK
  Top 0.254: E25.10 197.87,41.91 196.6,43.18 196.6,56.39 193.29,59.69 E24.12 | E33.6 145.29,11.68 146.3,10.67 154.94,10.67 154.94,60.2 157.48,62.74 162.05,62.74 162.05,61.98 E28.15 162.31,59.69 162.31,56.64 160.27,54.61 E28.1
  Bottom 0.254: E24.12 192.53,61.98 191.77,62.74 163.83,62.74 163.07,61.98 E28.15
PANLOCK\  (via drill 0.61)
  Top 0.254: v189.99,83.82 189.99,62.48 190.25,62.23 E24.13 | v173.99,87.63 172.97,88.65 v172.97,91.19 | v105.16,90.17 90.93,75.95 80.01,75.95 80.01,78.99 78.99,80.01 73.91,80.01 73.91,79.25 J2.6
  Bottom 0.254: v189.99,83.82 189.48,83.31 178.31,83.31 v173.99,87.63 | v172.97,91.19 172.47,91.69 143.51,91.69 141.99,90.17 v105.16,90.17 | R31.2 7.11,78.49 9.14,76.45 71.12,76.45 73.15,78.49 J2.6
POWCK  (via drill 0.61)
  Top 0.254: v193.04,65.28 193.04,64.52 195.33,62.23 E24.11 | v56.13,68.58 46.23,78.49 J2.28 45.47,79.25 45.47,80.01 42.93,80.01 41.91,78.99 41.91,78.49 42.16,78.23 42.16,68.33 28.7,54.86 28.7,38.35 16,25.65 R33.2
  Bottom 0.254: v193.04,65.28 185.93,65.28 185.17,66.04 175.01,66.04 174.5,66.55 168.66,66.55 168.15,67.06 152.15,67.06 151.89,66.8 131.32,66.8 130.3,65.79 118.11,65.79 117.86,65.53 81.79,65.53 81.28,66.04 58.67,66.04 v56.13,68.58
PULSELOADADD\  (via drill 0.61)
  Top 0.254: v144.78,56.9 147.07,54.61 E31.7 | v77.98,60.45 69.6,68.83 v69.6,77.47
  Bottom 0.254: v144.78,56.9 144.53,56.64 116.33,56.64 112.78,60.2 112.78,62.74 80.26,62.74 v77.98,60.45 | v69.6,77.47 32,77.47 30.99,78.49 J2.40
RUN\  (via drill 0.61)
  Top 0.254: 57.91,11.18 9.4,11.18 8.13,12.45 R28.1 | 57.91,11.18 57.91,37.85 J1.18 | v197.61,48.51 197.61,51.82 197.87,52.07 E24.5 | v187.96,48.51 184.66,45.21 184.66,40.39 183.64,39.37 v183.64,26.67 | v169.42,25.4 168.66,24.64 168.66,12.7 v161.29,5.33 | v124.46,5.33 99.57,5.33 99.57,7.37 95.76,11.18 57.91,11.18
  Bottom 0.254: v187.96,48.51 v197.61,48.51 | v183.64,26.67 182.37,25.4 v169.42,25.4 | v124.46,5.33 v161.29,5.33
SHLT\
  Bottom 0.254: J3.5 142.75,72.64 143.51,71.88 159.51,71.88 E27.1
SINGSTEP\  (via drill 0.61)
  Top 0.254: v167.64,65.53 167.64,62.23 E28.13 | v87.12,69.6 v92.2,64.52 | v65.28,72.9 63.75,74.42 63.75,78.23 J2.14
  Bottom 0.254: v167.64,65.53 167.39,65.79 141.48,65.79 140.46,64.77 133.86,64.77 133.35,65.28 118.36,65.28 117.6,64.52 v92.2,64.52 | v87.12,69.6 83.82,72.9 v65.28,72.9
SRDATA\  (via drill 0.61)
  Top 0.254: v130.81,27.69 130.81,35.81 134.37,39.37 E32.13 134.62,41.91 v134.62,43.94 | v311.4,48.51 311.4,71.63 312.17,72.39 E8.1 | J2.30 42.93,78.23 42.67,77.98 42.67,54.36 29.21,40.89 29.21,37.59 15.75,24.13 10.41,24.13 10.41,24.64 R29.2
  Bottom 0.254: v130.81,27.69 12.95,27.69 | 12.95,27.69 10.92,25.65 R29.2 | v311.4,48.51 307.85,44.96 277.62,44.96 276.1,43.43 225.3,43.43 223.77,44.96 223.27,44.96 222.25,43.94 180.34,43.94 179.32,44.96 178.82,44.96 177.29,43.43 135.13,43.43 v134.62,43.94 | 12.95,27.69 12.95,34.8 R30.1
STATE\  (via drill 0.61)
  Top 0.254: v113.79,68.07 113.79,65.02 116.59,62.23 E34.11 | v36.07,75.44 33.27,78.23 J2.38
  Bottom 0.254: v113.79,68.07 80.26,68.07 78.74,69.6 41.91,69.6 v36.07,75.44
STHIS\
  Bottom 0.254: J3.4 140.21,74.68 141.22,75.69 189.74,75.69 191.77,73.66 211.07,73.66 212.85,71.88 214.63,71.88 215.39,72.64 E20.2
THIS  (via drill 0.61)
  Top 0.254: v174.24,65.53 170.69,61.98 E28.12 | v223.01,65.28 223.27,65.53 223.27,72.39 E20.5
  Bottom 0.254: v174.24,65.53 184.91,65.53 186.18,64.26 211.07,64.26 212.09,65.28 v223.01,65.28
TS1\  (via drill 0.61)
  Top 0.254: v218.44,63.25 218.44,72.39 E20.3 | J1.26 47.75,38.35 46.99,38.35 45.97,39.37 44.45,39.37 44.45,37.34 20.83,13.72 17.27,13.72 16.26,12.7 16.26,12.19 15.75,11.68 10.41,11.68 10.41,11.94 R26.2 | v179.58,9.65 180.59,10.67 185.67,10.67 185.67,10.16 v189.99,5.84 | v240.28,6.6 243.33,9.65 v243.33,9.91 | v239.27,10.41 239.78,10.92 239.78,44.96 v238.76,45.97 | v234.19,45.97 230.12,50.04 v230.12,61.72
  Bottom 0.254: 218.44,62.74 222.25,62.74 | 218.44,62.74 201.93,62.74 201.17,61.98 E24.9 | 222.25,62.74 223.01,61.98 E21.10 | 218.44,62.74 v218.44,63.25 | R27.1 5.84,12.45 6.6,11.68 8.64,11.68 9.4,12.45 R26.2 10.92,12.45 12.7,10.67 112.01,10.67 118.36,4.32 129.79,4.32 130.3,4.83 160.53,4.83 161.04,4.32 173.48,4.32 178.82,9.65 v179.58,9.65 | v189.99,5.84 239.52,5.84 v240.28,6.6 | v243.33,9.91 242.82,10.41 v239.27,10.41 | v234.19,45.97 v238.76,45.97 | v230.12,61.72 229.11,62.74 222.25,62.74
VCC  (via drill 0.61)
  Top 0.508: E27.14 159.51,78.99 158.24,78.99 C27.2 | 130.81,59.94 130.3,59.94 C31.2 129.54,60.45 v129.54,80.52 | 130.81,59.94 131.57,59.94 E31.16 | 130.81,59.94 130.81,42.93 131.83,41.91 E32.14 131.57,39.62 130.3,39.62 C32.2 129.29,38.61 129.29,35.81 128.27,34.8 128.27,25.15 131.83,21.59 E33.14 131.57,19.3 130.3,19.3 C33.2 | v134.37,78.49 132.59,80.26 J3.16 | R35.1 17.27,22.61 15.75,22.61 R34.1 14.73,22.61 13.21,22.61 R36.1 12.19,22.61 10.92,22.61 R26.1 9.4,22.61 8.13,22.61 R28.2 7.87,23.37 7.87,32.77 9.91,34.8 R29.1 10.16,36.32 10.16,52.32 8.38,54.1 VCC.1 8.38,57.66 8.38,63.75 9.65,65.02 C38.+ 11.18,65.53 14.22,65.53 C39.+ | J2.9 69.09,81.03 70.61,81.03 J2.7 71.63,81.03 73.15,81.03 J2.5 74.17,81.03 75.69,81.03 J2.3 76.71,81.03 78.23,81.03 J2.1 | E34.16 103.63,59.94 102.36,59.94 C34.2 | J4.16 103.89,80.01 101.6,77.72 101.6,60.45 C34.2 | E36.6 116.59,15.24 116.59,20.32 E36.11 116.59,22.86 116.59,31.75 E35.6 | J1.3 75.95,40.13 75.95,38.61 J1.4 76.71,37.85 78.23,37.85 J1.2 78.49,38.61 78.49,40.13 J1.1 | J1.9 69.09,40.39 70.61,40.39 J1.7 | E36.1 103.89,15.24 103.89,20.32 E36.16 103.63,20.57 102.87,20.57 | 102.87,20.57 102.36,20.57 C36.2 | 102.87,20.57 102.87,34.29 103.63,35.05 103.63,39.12 103.89,39.37 E35.16 | C34.2 101.35,58.93 100.33,57.91 100.33,41.15 101.35,40.13 C35.2 | 295.91,44.45 296.93,44.45 296.93,41.91 | 295.91,44.45 295.4,44.45 294.89,43.94 294.89,43.69 292.35,41.15 R8.2 | 296.93,41.91 296.93,41.15 R6.2 | 296.93,41.91 300.74,41.91 301.75,40.89 R5.2 302.01,40.13 300.99,39.12 300.99,24.13 | E10.20 311.91,39.62 310.64,39.62 C10.2 310.13,38.61 311.15,37.59 311.15,31.75 310.13,30.73 310.13,19.81 C11.2
  Top 0.508: 300.99,24.13 302.01,24.13 302.01,23.37 R9.2 | 300.99,24.13 298.7,24.13 297.69,23.11 R10.2 296.93,22.35 295.91,21.34 295.91,11.43 293.62,11.43 292.61,12.45 R11.2 | 311.15,80.26 310.64,80.26 C8.2 309.63,79.25 302.51,72.14 302.51,64.01 R15.2 | 311.15,80.26 311.91,80.26 E8.14 | 311.15,80.26 311.15,74.42 310.64,73.91 310.64,60.96 310.13,60.45 C9.2 | R7.2 286.77,41.15 285.24,42.67 285.24,61.47 286.77,62.99 R13.2 287.27,64.01 287.27,64.77 290.58,64.77 291.59,63.75 R14.2 | 295.91,44.45 295.91,53.85 296.93,54.86 296.93,62.99 R16.2 | C3.2 369.06,19.3 370.33,19.3 E3.14 371.09,21.59 372.11,22.61 372.11,38.35 371.09,39.37 E2.14 | C2.2 368.05,40.13 367.03,41.15 367.03,57.91 368.05,58.93 C1.2 369.06,59.94 370.33,59.94 E1.14 370.59,62.23 364.49,68.33 364.49,80.77 365.51,81.79 R25.2 | E4.11 356.11,80.26 357.63,80.26 E4.10 | E6.16 343.15,39.37 344.17,38.35 344.17,22.61 343.15,21.59 E7.16 | 341.63,59.94 341.12,59.94 C5.2 340.11,58.93 339.09,57.91 339.09,41.15 340.11,40.13 C6.2 340.61,38.61 340.61,37.08 341.63,36.07 341.63,33.78 341.12,33.27 341.12,20.32 340.61,19.81 C7.2 | 341.63,59.94 342.39,59.94 E5.16 | 341.63,59.94 341.63,78.23 340.61,79.25 C4.2 | E20.14 212.85,80.26 211.58,80.26 C20.2 | E16.4 244.09,74.93 246.13,76.96 246.13,80.01 E16.10 | E20.10 224.03,82.3 224.79,83.06 233.43,83.06 233.43,80.77 C16.2 | E15.16 264.41,22.86 265.43,23.88 265.43,35.81 264.41,36.83 264.41,39.37 E14.16 264.41,41.91 265.43,42.93 265.43,56.9 264.41,57.91 264.41,59.69 E13.16 264.41,62.23 264.92,62.74 264.92,64.26 | 264.92,64.26 264.92,70.61 265.43,71.12 265.43,77.72 264.41,78.74 E12.16 263.65,78.99 262.38,78.99 C12.2 261.37,79.5 261.37,88.14 239.27,88.14 238,86.87 238,84.07 236.47,82.55 E16.14
  Top 0.508: E18.16 235.71,39.62 234.44,39.62 C18.2 233.93,38.61 234.95,37.59 234.95,31.75 233.93,30.73 233.93,19.81 C19.2 | E26.5 198.37,15.24 198.63,15.49 v198.63,18.29 198.88,18.54 199.39,19.05 199.39,23.37 197.61,23.37 195.33,25.65 195.33,31.75 E25.4 | C23.2 211.58,19.3 212.85,19.3 E23.14 213.11,21.59 211.84,22.86 211.84,33.53 212.09,33.78 212.09,39.62 | v172.72,36.58 172.72,34.29 E29.6 | v184.66,36.58 185.17,37.08 185.17,38.61 C25.2 | E28.16 159.51,59.94 158.24,59.94 C28.2 156.97,59.18 155.7,57.91 155.7,45.97 159.77,41.91 E29.16 159.51,39.62 158.75,39.62 | 158.75,39.62 158.24,39.62 C29.2 | 158.75,39.62 158.75,36.58 | 158.75,36.58 158.75,23.88 159.77,22.86 E30.14 | 158.75,36.58 v160.27,36.58 | 212.09,39.62 211.58,39.62 C22.2 | 212.09,39.62 212.85,39.62 E22.14 213.11,41.91 212.09,42.93 212.09,59.94 | 212.09,59.94 211.58,59.94 C21.2 | 212.09,59.94 212.85,59.94 E21.14 | 264.92,64.26 v264.67,64.26 | v155.96,25.65 156.97,24.64 156.97,20.83 C30.2
  Bottom 0.508: E34.10 119.89,59.94 120.65,59.18 129.03,59.18 C31.2 | v129.54,80.52 131.57,80.52 J3.16 | v134.37,78.49 134.62,78.74 156.72,78.74 C27.2 | R29.1 10.92,35.81 11.94,36.83 13.46,36.83 14.48,35.81 R33.1 | R31.1 7.11,68.33 8.89,66.55 9.14,66.55 C38.+ | J2.1 79.25,81.53 80.52,82.8 103.12,82.8 103.63,82.3 J4.16 | 115.7,19.94 116.33,20.57 E36.11 117.35,22.61 119.89,25.15 152.4,25.15 152.91,25.65 v155.96,25.65 | 115.7,19.94 115.57,19.81 113.03,19.81 112.27,20.57 E36.13 111.25,20.57 110.49,19.81 102.11,19.81 C36.2 100.84,20.57 20.32,20.57 18.29,22.61 R35.1 | C33.2 128.78,19.3 128.27,19.81 115.82,19.81 115.7,19.94 | J1.7 71.63,40.39 73.15,40.39 J1.5 74.17,40.39 75.69,40.39 J1.3 | E35.16 103.63,39.62 102.36,39.62 C35.2 100.84,39.62 98.3,42.16 80.52,42.16 79.25,40.89 J1.1 | R12.2 287.53,12.45 288.54,11.43 290.58,11.43 291.59,12.45 R11.2 | E11.20 311.91,19.3 310.64,19.3 C11.2 309.12,19.3 306.83,21.59 303.78,21.59 302.77,22.61 R9.2 | E9.20 311.91,59.94 310.64,59.94 C9.2 | R32.1 297.94,81.03 298.7,80.26 309.12,80.26 C8.2 | 295.78,62.36 296.67,63.25 R16.2 | 295.78,62.36 295.66,62.23 293.62,62.23 292.61,63.25 R14.2 | R15.2 301.75,63.25 300.74,62.23 295.91,62.23 295.78,62.36 | E2.14 370.33,39.62 369.06,39.62 C2.2 | C4.2 341.12,80.26 342.39,80.26 E4.16 343.41,80.26 344.17,79.5 354.33,79.5 355.09,80.26 E4.11 | R25.2 365,82.8 364.74,83.06 359.41,83.06 358.65,82.3 E4.10 | E7.16 342.39,19.3 341.12,19.3 C7.2 | E10.20 312.93,39.62 314.45,38.1 338.58,38.1 339.6,39.12 C6.2 | E20.10 223.01,82.3 222.25,83.06 214.63,83.06 213.87,82.3 E20.14 | C16.2 234.44,80.26 235.71,80.26 E16.14 236.73,80.26 237.49,79.5 245.11,79.5 245.87,80.26 E16.10
  Bottom 0.508: E15.16 263.65,20.57 262.38,20.57 C15.2 | E14.16 263.65,39.62 262.38,39.62 C14.2 | E13.16 263.65,59.94 262.38,59.94 C13.2 260.86,59.44 260.6,59.18 234.19,59.18 C17.2 | E19.16 235.71,19.3 234.44,19.3 C19.2 232.92,19.3 232.41,19.3 226.69,25.02 | 226.69,25.02 226.57,25.15 | C26.2 186.18,20.07 187.71,18.54 198.37,18.54 v198.63,18.29 199.14,18.8 210.06,18.8 C23.2 211.33,18.54 222.25,18.54 222.25,21.84 225.43,25.02 | 225.43,25.02 225.55,25.15 | v184.66,36.58 v172.72,36.58 172.47,36.32 160.53,36.32 v160.27,36.58 | E25.14 187.45,39.62 186.18,39.62 C25.2 | E30.14 159.51,20.57 158.24,20.57 C30.2 | E17.16 235.71,59.94 234.44,59.94 C17.2 | C24.2 186.18,59.94 187.45,59.94 E24.14 188.47,59.94 189.23,59.18 196.34,59.18 196.85,59.69 196.85,62.74 | 196.85,62.74 198.88,62.74 199.39,62.23 199.39,59.18 210.31,59.18 C21.2 211.33,59.18 232.66,59.18 232.92,59.44 C17.2 | 196.85,62.74 196.09,63.5 162.05,63.5 160.53,61.98 E28.16 | v264.67,64.26 264.92,64.01 286.26,64.01 286.51,63.75 R13.2 | E25.3 193.55,32 195.07,32 E25.4 | 225.43,25.02 225.55,24.89 226.57,24.89 226.69,25.02

## Text on the board
Top: CEM/VRS | PDP-8/A Console, Board 2 | Revision A
Bottom: Warning - VCC Fill | Warning - VCC Fill | Warning - VCC Fill | CEM/VRS | PDP-8/A Console, Board 2 | Revision A
tPlace: Revision A
tValues: A | VV | A | VV | CEM/VRS | PDP-8/A Console, Board 2